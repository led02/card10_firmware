# Keil uVision project tag-bt4.uvprojx, settings and files
target tag-bt4 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: tag-bt4-obj +hex
  AfterMake: fromelf.exe --bin --output _build/tag-bt4-obj.bin _build/tag-bt4-obj.axf
  AfterMake: python ../../../../platform/bt4/build/pack_all.py  _build/tag-bt4-obj.bin  ../../../../platform/bt4/img/ASIC-2.2-ble_ctr.img _build/tag-bt4-obj.img  _build/tag-bt4-obj.spf old
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: INIT_WAKEUP=1 INIT_FLASH=1 INIT_GPO=1 CONFIG_ALLOW_SETTING_WRITE=TRUE CONFIG_ALLOW_DEEP_SLEEP=FALSE WSF_MS_PER_TICK=10 INIT_PERIPHERAL WSF_PRINTF_MAX_LEN=128 WDXS_INCLUDED=1 INIT_ENCRYPTED BT_VER=8 CONFIG_HOST_TYPE_ASIC=1 WSF_BUF_STATS=1 WSF_BUF_ALLOC_FAIL_ASSERT=0 WSF_TRACE_ENABLED=1 CONFIG_HOST_REV=0x22 WSF_CS_STATS=1 WSF_MAX_HANDLERS=20
  c misc: --wchar16 --diag_suppress=1296
  c include: ..\..\..\..\ble-profiles\include\app;..\..\..\..\ble-profiles\sources\apps;..\..\..\..\ble-profiles\sources\apps\app;..\..\..\..\ble-profiles\sources\services;..\..\..\..\ble-profiles\sources\profiles\include;..\..\..\..\ble-profiles\sources\profiles;..\..\..\..\ble-host\include;..\..\..\..\ble-host\sources\stack\att;..\..\..\..\ble-host\sources\stack\cfg;..\..\..\..\ble-host\sources\stack\dm;..\..\..\..\ble-host\sources\stack\hci;..\..\..\..\ble-host\sources\stack\l2c;..\..\..\..\ble-host\sources\stack\smp;..\..\..\..\platform\common\include;..\..\..\..\ble-host\sources\hci\dual_chip;..\..\..\..\wsf\common\include;..\..\..\..\controller\sources\ble\include;..\..\..\..\controller\include\ble;..\..\..\..\controller\include\common;..\..\..\..\platform\common\include;..\..\..\..\platform\bt4\include;..\..\..\..\platform\bt4\sources\board\CMSIS\Device\SMD\TC\Include;..\..\..\..\platform\bt4\sources\board\CMSIS\Include;..\..\..\..\platform\bt4\sources\llc\include;..\..\..\..\platform\bt4\sources\board;..\..\..\..\platform\bt4\sw\llc\include
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\platform\bt4\build\cordio_tc-ram.sct
  group ble-host
    ../../../../ble-host/sources/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../ble-host/sources/stack/dm/: dm_adv.c dm_adv_leg.c dm_conn.c dm_conn_master.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_priv.c dm_scan.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c
    ../../../../ble-host/sources/hci/dual_chip/: hci_cmd.c hci_core_ps.c hci_evt.c
    ../../../../ble-host/sources/hci/common/: hci_core.c
    ../../../../ble-host/sources/stack/hci/: hci_main.c
    ../../../../ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../ble-host/sources/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../../ble-host/sources/stack/smp/: smp_act.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
  group ble-profiles
    ../../../../ble-profiles/sources/profiles/anpc/: anpc_main.c
    ../../../../ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c
    ../../../../ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../ble-profiles/sources/profiles/bas/: bas_main.c
    ../../../../ble-profiles/sources/profiles/blpc/: blpc_main.c
    ../../../../ble-profiles/sources/profiles/blps/: blps_main.c
    ../../../../ble-profiles/sources/profiles/cpp/: cpps_main.c
    ../../../../ble-profiles/sources/profiles/cscp/: cscps_main.c
    ../../../../ble-profiles/sources/profiles/dis/: dis_main.c
    ../../../../ble-profiles/sources/profiles/fmpl/: fmpl_main.c
    ../../../../ble-profiles/sources/profiles/gap/: gap_main.c
    ../../../../ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../ble-profiles/sources/profiles/glpc/: glpc_main.c
    ../../../../ble-profiles/sources/profiles/glps/: glps_db.c glps_main.c
    ../../../../ble-profiles/sources/profiles/sensor/: gyro_main.c temp_main.c
    ../../../../ble-profiles/sources/profiles/hid/: hid_main.c
    ../../../../ble-profiles/sources/apps/hidapp/: hidapp_main.c
    ../../../../ble-profiles/sources/profiles/hrpc/: hrpc_main.c
    ../../../../ble-profiles/sources/profiles/hrps/: hrps_main.c
    ../../../../ble-profiles/sources/profiles/htpc/: htpc_main.c
    ../../../../ble-profiles/sources/profiles/htps/: htps_main.c
    ../../../../ble-profiles/sources/profiles/paspc/: paspc_main.c
    ../../../../ble-profiles/sources/profiles/plxpc/: plxpc_main.c
    ../../../../ble-profiles/sources/profiles/plxps/: plxps_db.c plxps_main.c
    ../../../../ble-profiles/sources/profiles/rscp/: rscps_main.c
    ../../../../ble-profiles/sources/profiles/scpps/: scpps_main.c
    ../../../../ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../ble-profiles/sources/apps/tag/: tag_main_wdxs.c
    ../../../../ble-profiles/sources/profiles/tipc/: tipc_main.c
    ../../../../ble-profiles/sources/profiles/udsc/: udsc_main.c
    ../../../../ble-profiles/sources/profiles/uribeacon/: uricfg_main.c
    ../../../../ble-profiles/sources/profiles/wdxc/: wdxc_ft.c wdxc_main.c wdxc_stream.c
    ../../../../ble-profiles/sources/profiles/wdxs/: wdxs_au.c wdxs_dc.c wdxs_ft.c wdxs_main.c wdxs_stream.c
    ../../../../ble-profiles/sources/apps/wdxs/: wdxs_oad.c
    ../../../../ble-profiles/sources/profiles/wpc/: wpc_main.c
    ../../../../ble-profiles/sources/profiles/wspc/: wspc_main.c
    ../../../../ble-profiles/sources/profiles/wsps/: wsps_main.c
  group platform-bt4
    ../../../../platform/bt4/sources/app/: app_param.c
    ../../../../platform/bt4/sources/board/: board.c board_flash.c board_heap.c board_main.c board_rtc.c board_time.c board_ui.c board_wsf.c cordio_tc2.c platform.c
    ../../../../platform/bt4/sources/hci/: hci_tr.c hci_vs.c
    ../../../../platform/bt4/sources/llc/cordio-tc2/: llc.c
    ../../../../platform/bt4/sources/llc/generic/: llc_hci.c llc_init.c
    ../../../../platform/bt4/sources/ota/: ota_common.c ota_efs.c
    ../../../../platform/bt4/sources/board/CMSIS/Device/SMD/TC/Source/ARM/: startup_smd_tc.s
    ../../../../platform/bt4/sources/board/CMSIS/Device/SMD/TC/Source/: system_smd_tc.c
  group projects
    ../../../../projects/ble-apps/tag/: main.c stack_tag.c
  group wsf
    ../../../../wsf/common/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../wsf/baremetal/sources/: wsf_assert.c wsf_buf.c wsf_cs.c wsf_efs.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
